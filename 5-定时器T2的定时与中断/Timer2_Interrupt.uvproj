# Keil uVision project Timer2_Interrupt.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH559 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: Timer2_Interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Timer2.C CH559.H
